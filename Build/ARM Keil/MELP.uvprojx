# Keil uVision project MELP.uvprojx, settings and files
target MELP (ARM-ADS)
  device: STM32F407IETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MELP
  c flags: Optim=4 oTime=1
  c define: __DBG_ITM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source
    ../../: coeff.c dsp_sub.c fec_code.c fs_lib.c fsvq_cb.c lpc_lib.c mat_lib.c melp.c melp_ana.c melp_chn.c melp_sub.c melp_syn.c msvq_cb.c pit_lib.c vq_lib.c
  group Retarget
    ../../ARM/: Retarget.c Serial.c
  group ::CMSIS
    C:/Keil5.0/ARM/PACK/ARM/CMSIS/4.2.0/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
  group ::Device
    RTE/Device/STM32F407IETx/: startup_stm32f407xx.s system_stm32f4xx.c
software components: CMSIS:CORE 3.40.0, CMSIS:DSP 1.4.2, Device:Startup 2.1.0
